require v3d-libgles-dags.inc

SRCDATE = "20170314"

SRC_URI[md5sum] = "89db82aba385bdbb1bf52fa200d866b4"
SRC_URI[sha256sum] = "67ce61810ceef90ff6052f639a2b0bee3f97dd150bde1526a79131be1dacee36"

COMPATIBLE_MACHINE = "^(force3uhdplus|tm4ksuper|lunix34k|galaxy4k|force3uhd|tmtwin4k|revo4k)$"
